## src/systemcmds/dbactuator_step/Kconfig
```kconfig
menuconfig SYSTEMCMDS_DBACTUATOR_STEP
	bool "dbactuator_step"
	default n
	---help---
		Enable support for dbactuator_step
```
